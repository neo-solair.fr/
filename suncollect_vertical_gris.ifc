Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2], ExchangeRequirement [Architecture], Option [Elements to export: Visible elements (on all stories)], Option [Partial Structure Display: Entire Model], Option [IFC Domain: Custom], Option [Structural Function: All Elements], Option [Convert Grid elements: On], Option [Convert IFC Annotations and Archicad 2D elements: Off], Option [Convert 2D symbols of Doors and Windows: On], Option [Export geometries that Participates in Collision Detection only: On], Option [Split complex elements: Off], Option [Material Preservation: Explode where necessary], Option [IFC Model position: Survey Point only], Option [Curtain Wall export mode: Single Element], Option [Railing export mode: Single Element], Option [Stair export mode: Single Element], Option [Properties To Export: Current Scheme properties only], Option [Space containment: Off], Option [Geometry to type objects: Off], Option [Element Properties: Off], Option [Building Material Properties: Off], Option [Element Parameters: Off], Option [Component Parameters: Off], Option [IFC Base Quantities: Off], Option [Door Window Parameters: Off], Option [IFC Space boundaries: Off], Option [Archicad Zone Categories as IFC Space classification data: Off], Option [Element Classifications: On]
File name: C:\Users\amand\Documents\Cours 4A\Stage\Boisurel\suncollect_vertical_gris.ifc
Time: 2026-05-20T15:51:14
Author: Architect
Organization: BOISUREL
Written by: DDS_IFC v3.0
Made in: Graphisoft - Archicad - 29.1.0
Authorization: The authorising person

# IfcProject, Projet
Description: Le panneau solaire thermique développé par l’entreprise BOISUREL permet d’assurer un chauffage écoresponsable du logement. En chauffant l’air extérieur avant de l’injecter à l’intérieur, il contribue également à améliorer la qualité de l’air. Durant l’été, il peut aussi participer au rafraîchissement du bâtiment en insufflant de l’air frais pendant la nuit.

# IfcSite, Site
RefLatitude: 43, 43, 23, 171230; RefLongitude: 1, 23, 1, 910000; RefElevation: 146 m

# IfcBuildingStorey, Rez-de-chaussée
In: Bâtiment
Elevation: 0 m

# IfcBuildingElementProxy: Suncollect, MOBILIER-022
In: Rez-de-chaussée
Material: Aluminium, Bois aggloméré, Vitrage
Pset_BuildingElementProxyCommon - Status: EXISTING
Pset_ManufacturerTypeInformation - Manufacturer: BOISUREL
